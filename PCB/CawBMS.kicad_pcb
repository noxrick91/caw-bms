# Repository noxrick91/caw-bms

## KiCad design PCB/CawBMS.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C44: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C37: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C38, C39: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C40, C41: 18pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C42, C43: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CN1: SPI; CONN-SMD_6P-P1.00_XUNPU_WAFER-SH1.0-6PWB
CN2: WAFER-SH1.0-6PWB; CONN-SMD_6P-P1.00_XUNPU_WAFER-SH1.0-6PWB
CN5: SWD; CONN-SMD_4P-P1.00_WAFER-SH1.0-4PWB
D1, D2: LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad_Via
IC1: LM66200DRLR
L1: 39nH; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
R1, R4: 10k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2, R5: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R7, R8, R13, R46, R47: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R9: 120Ω 1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R10, R11: 510; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
TP1: TestPoint; TestPoint_Pad_D1.0mm
U1, U2: WAFER-SH1.0-2PWB; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
U3: STM32L431CCUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U5: CAN; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
U6: TJA1051T/3/1J; TJA1051T31J_SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL
U9: TLV76733DRVR; TLV76733DRVR_SON65P200X200X80-7N
U10, U12: KEY; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
X1: Crystal_16MHz_15pF_3P; Crystal_SMD3213-3P; JLC Part Number C341521
XTAL1: Q13FC1350000400

Connections:
+3.3V: C3.2, C5.1, C6.1, C7.1, C42.2, CN2.3, IC1.3 (VIN1), L1.1, R7.1, R8.1, R13.1, R46.2, U3.24 (VDD), U3.36 (VDD), U3.48 (VDD); also elsewhere on the board
+3.3VA: C9.1, L1.2, U3.9 (VDDA); also elsewhere on the board
+3V3: C10.2, C38.1, C39.1, CN1.6, CN5.3, D1.2 (A), R1.2, R4.2, U6.5 (VIO), U9.1 (OUT), U9.2 (SNS)
+5V: C8.1, C37.1, CN5.4, U6.3 (VCC), U9.4 (EN), U9.6 (IN); also elsewhere on the board
/ADC1_IN5: C1.2, R1.1, U1.1, U3.10 (PA0); also elsewhere on the board
/ADC1_IN6: C2.2, R4.1, U2.1, U3.11 (PA1); also elsewhere on the board
/CAN_N: R9.1, U5.1, U6.6 (CANL)
/CAN_P: R9.2, U5.2, U6.7 (CANH)
/CAN_RX: U3.32 (PA11), U6.4 (RXD); also elsewhere on the board
/CAN_STB: U3.31 (PA10), U6.8 (S); also elsewhere on the board
/CAN_TX: U3.33 (PA12), U6.1 (TXD); also elsewhere on the board
/HSE_IN: U3.5 (PH0), X1.1 (OSC1); also elsewhere on the board
/HSE_OUT: U3.6 (PH1), X1.3 (OSC2); also elsewhere on the board
/I2C2_SCL: R7.2, U3.21 (PB10); also elsewhere on the board
/I2C2_SDA: R8.2, U3.22 (PB11); also elsewhere on the board
/KEY_A: U3.30 (PA9), U10.1; also elsewhere on the board
/RCC_OSC32_IN: C40.1, U3.3 (PC14), XTAL1.1; also elsewhere on the board
/RCC_OSC32_OUT: R2.2, U3.4 (PC15); also elsewhere on the board
/RESET: C11.1, R13.2, U3.7 (NRST); also elsewhere on the board
/SPI1_MISO: CN1.3, U3.40 (PB4); also elsewhere on the board
/SPI1_MOSI: CN1.4, U3.41 (PB5); also elsewhere on the board
/SPI1_NSS: CN1.1, U3.38 (PA15); also elsewhere on the board
/SPI1_SCK: CN1.2, U3.39 (PB3); also elsewhere on the board
/STA_LED: D2.2 (A), U3.26 (PB13); also elsewhere on the board
/SWCLK: CN2.6, R47.2, U3.37 (PA14); also elsewhere on the board
/SWDIO: CN2.5, R46.1, U3.34 (PA13); also elsewhere on the board
/USART1_RX: CN2.1, U3.43 (PB7); also elsewhere on the board
/USART1_TX: CN2.2, U3.42 (PB6); also elsewhere on the board
/VBAT: C4.1, IC1.2 (VOUT@1), IC1.7 (VOUT@2), R6.2, U3.1 (VBAT); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.1, C43.1, C44.1, CN1.5, CN2.4, CN5.1, CN5.2, IC1.1 (GND@1), IC1.4 (ON), IC1.5 (GND@2), R3.1, R5.2, R10.2, R11.2, R47.1, U1.2, U2.2, U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U3.49 (VSS), U6.2 (GND), U9.3 (GND), U9.5 (GND), U9.7 (NC), U10.2, U12.1, X1.2 (GND); also elsewhere on the board
unnamed: C41.1, R2.1, XTAL1.2
unnamed: D1.1 (K), R10.1
unnamed: D2.1 (K), R11.1
unnamed: IC1.8 (ST), R6.1, TP1.1
unnamed: C43.2, C44.2, IC1.6 (VIN2), U12.2
unnamed 78: R3.2, U3.44 (PH3); also elsewhere on the board
unnamed 79: R5.1, U3.8 (VSSA); also elsewhere on the board

Notes on the sheet:
降压电路(3.3V)

Parts:
C30, C31: 4.7uF 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C32: 0.01uF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C33, C35: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C34: HV1C337M0607PZ; CP_Elec_6.3x5.8
D13: B540C-13-F; PARTREV V1.0
L6: ZEMS0650-150M; L_7.3x7.3_H3.5
R43: 10k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R44: 3.16k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U8: TPS5450DDAR; PARTREV D

Connections:
+5V: C34.1, C35.2, L6.2, R43.1; also elsewhere on the board
/5V_EN: U8.5 (ENA); also elsewhere on the board
GND: C30.2, C31.2, C32.2, C34.2, C35.1, D13.A, R44.2, U8.6 (GND), U8.9 (POWERPAD); also elsewhere on the board
unnamed: C33.2, D13.C, L6.1, U8.1 (BOOT)
unnamed: C33.1, U8.8 (PH)
unnamed: R43.2, R44.1, U8.4 (VSENSE)
PACK+: C30.1, C31.1, C32.1, U8.7 (VIN); also elsewhere on the board

Parts:
C12, C13, C14, C15, C16, C17: 0.22uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C18: 4.7uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C19, C20: 1uF 50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C21: 10uF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22, C23, C24, C36: 0.1uF 50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C25: 470pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C26, C27, C28, C29: 0.1uF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CN6: WAFER-SH1.0-6PWB; CONN-SMD_6P-P1.00_XUNPU_WAFER-SH1.0-6PWB
D4, D5, D6, D7, D8: EDZVT2R5.6B; D_SOD-523
D9: 1N4148WS T4; D_SOD-323_HandSoldering
D10: BZX585-B16,115; D_SOD-523
D11: ES1D; D_SMA_Handsoldering
D12: SMAJ24CA; D_SMA_Handsoldering
H5: P+; POWER_PAD; not fitted
H6: P-; POWER_PAD; not fitted
H7: B+; POWER_PAD; not fitted
H8: B-; POWER_PAD; not fitted
L2, L3, L4, L5: BLM18EG221SN1D; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1, Q2, Q3, Q4, Q5: CSD13381F4; CSD13381F4_PICOSTAR-3_L1.0-W0.6-P0.40-S0.65-BL-1
Q6, Q7, Q9, Q10: BSC0702LS; BSC0702LS_PG-TDSON-8_L5.0-W6.0-P1.27-BL-EP
Q8: TP0610K-T1-GE3; SOT-23
Q11: AO3400A; SOT-23
R12, R20, R22, R24, R26, R28, R31: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R14, R15, R16, R17, R18: 28.7; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
R19, R21, R23, R25, R27, R29, R32: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R30: NCP15XH103F03RC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R33, R37: 100 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R34, R35, R36: HoJLRX2512-2W-1.5mR-1%; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R38, R40, R41: 1M; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R39: 499k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R42: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R45: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R48: 75k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R49: 3k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U7: BQ7692003PW; BQ7692003PW_TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL
U11: WAFER-SH1.0-2PWB; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB

Connections:
+3.3V: C18.1, U7.8 (REGOUT); also elsewhere on the board
-BATT: D12.1 (A1), H8.1, R33.1, R34.1, R35.1, R36.1, R42.1
/ADC1_IN8: C36.1, R48.1, R49.2; also elsewhere on the board
/ALERT: C25.1, R39.2, U7.20 (ALERT); also elsewhere on the board
/BQ76920/BAT: C19.1, CN6.1, R14.1, R19.1, R32.1, U7.9 (REGSRC)
/BQ76920/CHG: Q8.2 (S), U7.2 (CHG)
/BQ76920/DSG: L2.1, L3.1, R38.2, U7.1 (DSG)
/BQ76920/SRN: C23.2, C24.1, R37.2, U7.19 (SRN)
/BQ76920/SRP: C22.2, C23.1, R33.2, U7.18 (SRP)
/BQ76920/VC0: C16.2, C17.1, R28.2, R29.2, U7.17 (VC0)
/BQ76920/VC1: C15.2, C16.1, R26.2, R27.2, U7.16 (VC1), U11.2
/BQ76920/VC2: C14.2, C15.1, R24.2, R25.2, U7.15 (VC2)
/BQ76920/VC3: C13.2, C14.1, R22.2, R23.2, U7.14 (VC3)
/BQ76920/VC4: C12.2, C13.1, R20.2, R21.2, U7.13 (VC4)
/BQ76920/VC5: C12.1, R19.2, U7.12 (VC5)
/EN_PRE_CHARGE: Q11.1 (G), R12.1; also elsewhere on the board
/I2C2_SCL: U7.5 (SCL); also elsewhere on the board
/I2C2_SDA: U7.4 (SDA); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.1, C21.2, C22.1, C24.2, C25.2, C36.2, Q8.1 (G), R12.2, R30.1, R39.1, R42.2, R49.1, U7.3 (VSS); also elsewhere on the board
unnamed: C26.1, Q6.1 (S), Q6.2 (S), Q6.3 (S), Q7.1 (S), Q7.2 (S), Q7.3 (S), R34.2, R35.2, R36.2, R37.1, R38.1, R45.2
unnamed: C26.2, C27.1
unnamed: C28.2, C29.1
unnamed: CN6.2, D4.2 (A), Q1.2 (S), R15.1, R21.1
unnamed: D4.1 (K), Q1.1 (G), R20.1
unnamed: CN6.3, D5.2 (A), Q2.2 (S), R16.1, R23.1
unnamed: D5.1 (K), Q2.1 (G), R22.1
unnamed: CN6.4, D6.2 (A), Q3.2 (S), R17.1, R25.1
unnamed: D6.1 (K), Q3.1 (G), R24.1
unnamed: CN6.5, D7.2 (A), Q4.2 (S), R18.1, R27.1
unnamed: D7.1 (K), Q4.1 (G), R26.1
unnamed: CN6.6, D8.2 (A), Q5.2 (S), R29.1
unnamed: D8.1 (K), Q5.1 (G), R28.1
unnamed: D9.2 (A), Q8.3 (D), R40.2
unnamed: D9.1 (K), D10.1 (K), L4.1, L5.1, R40.1, R41.2
unnamed: Q1.3 (D), R14.2
unnamed: Q2.3 (D), R15.2
unnamed: Q3.3 (D), R16.2
unnamed: Q4.3 (D), R17.2
unnamed: Q5.3 (D), R18.2
unnamed: L3.2, Q6.4 (G)
unnamed: L2.2, Q7.4 (G)
unnamed: L4.2, Q9.4 (G)
unnamed: Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D)
unnamed: L5.2, Q10.4 (G)
unnamed: Q11.2 (S), R45.1
unnamed: R31.1, U11.1
unnamed: C21.1, R32.2, U7.10 (BAT)
unnamed: C20.2, U7.7 (CAP1)
unnamed: R30.2, R31.2, U7.6 (TS1)
PACK+: C28.1, D11.1 (K), D12.2 (A2), H5.1, H7.1; also elsewhere on the board
PACK-: C27.2, C29.2, D10.2 (A), D11.2 (A), H6.1, Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.1 (S), Q10.2 (S), Q10.3 (S), Q11.3 (D), R41.1, R48.2

Board: 4 copper layers, 55.0 x 55.0 mm, 153 parts (1 on the bottom side), 88 nets.

Other parts of the board:
U4: STM32L431CCTx; LQFP-48_7x7mm_P0.5mm
kibuzzard-69B05E76: G***; kibuzzard-69B05E76
kibuzzard-69B5918C: G***; kibuzzard-69B5918C
kibuzzard-6582907D: G***; kibuzzard-6582907D
kibuzzard-65829086: G***; kibuzzard-65829086

Their connections:
+3.3V: U4.24 (VDD), U4.36 (VDD), U4.48 (VDD); also elsewhere on the board
+3.3VA: U4.9 (VDDA); also elsewhere on the board
/5V_EN: U4.25 (PB12); also elsewhere on the board
/ADC1_IN5: U4.10 (PA0); also elsewhere on the board
/ADC1_IN6: U4.11 (PA1); also elsewhere on the board
/ADC1_IN8: U4.13 (PA3); also elsewhere on the board
/ALERT: U4.14 (PA4); also elsewhere on the board
/CAN_RX: U4.32 (PA11); also elsewhere on the board
/CAN_STB: U4.31 (PA10); also elsewhere on the board
/CAN_TX: U4.33 (PA12); also elsewhere on the board
/EN_PRE_CHARGE: U4.19 (PB1); also elsewhere on the board
/HSE_IN: U4.5 (PH0); also elsewhere on the board
/HSE_OUT: U4.6 (PH1); also elsewhere on the board
/I2C2_SCL: U4.21 (PB10); also elsewhere on the board
/I2C2_SDA: U4.22 (PB11); also elsewhere on the board
/KEY_A: U4.30 (PA9); also elsewhere on the board
/RCC_OSC32_IN: U4.3 (PC14); also elsewhere on the board
/RCC_OSC32_OUT: U4.4 (PC15); also elsewhere on the board
/RESET: U4.7 (NRST); also elsewhere on the board
/SPI1_MISO: U4.40 (PB4); also elsewhere on the board
/SPI1_MOSI: U4.41 (PB5); also elsewhere on the board
/SPI1_NSS: U4.38 (PA15); also elsewhere on the board
/SPI1_SCK: U4.39 (PB3); also elsewhere on the board
/STA_LED: U4.26 (PB13); also elsewhere on the board
/SWCLK: U4.37 (PA14); also elsewhere on the board
/SWDIO: U4.34 (PA13); also elsewhere on the board
/USART1_RX: U4.43 (PB7); also elsewhere on the board
/USART1_TX: U4.42 (PB6); also elsewhere on the board
/VBAT: U4.1 (VBAT); also elsewhere on the board
GND: U4.23 (VSS), U4.35 (VSS), U4.47 (VSS); also elsewhere on the board
unnamed 78: U4.44 (PH3); also elsewhere on the board
unnamed 79: U4.8 (VSSA); also elsewhere on the board

## Code that names these connections

File caw-bms.ioc (part):

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Mcu.Name=STM32L431C(B-C)Ux
Mcu.Package=UFQFPN48
Mcu.UserName=STM32L431CCUx
PA0.Signal=ADCx_IN5
PA1.Signal=ADCx_IN6
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=CAN_STB
PA10.Signal=GPIO_Output
PA11.Mode=CAN_Activate
PA11.Signal=CAN1_RX
PA12.Mode=CAN_Activate
PA12.Signal=CAN1_TX
PA13\ (JTMS-SWDIO).Mode=Serial_Wire
PA13\ (JTMS-SWDIO).Signal=SYS_JTMS-SWDIO
PA14\ (JTCK-SWCLK).Mode=Serial_Wire
PA14\ (JTCK-SWCLK).Signal=SYS_JTCK-SWCLK
PA15\ (JTDI).Signal=SPI1_NSS
PA3.Signal=ADCx_IN8
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=ALERT
PA4.Signal=GPXTI4
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=KEY_A
PA9.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=EN_PRE_CHARGE
PB1.Signal=GPIO_Output
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=EN_5V
PB12.Signal=GPIO_Output
PB3\ (JTDO-TRACESWO).Mode=Full_Duplex_Master
PB3\ (JTDO-TRACESWO).Signal=SPI1_SCK
PB4\ (NJTRST).Mode=Full_Duplex_Master
PB4\ (NJTRST).Signal=SPI1_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI1_MOSI
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PC14-OSC32_IN\ (PC14).Mode=LSE-External-Oscillator
PC14-OSC32_IN\ (PC14).Signal=RCC_OSC32_IN
PC15-OSC32_OUT\ (PC15).Mode=LSE-External-Oscillator
PC15-OSC32_OUT\ (PC15).Signal=RCC_OSC32_OUT
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=80000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2026-03-03 feat(PCB): 新增预充功能; 支持2路电池温度采样; 支持低功耗模式; 更换主控芯片; 采用降压输出5V
2026-03-03 Add LICENSE file
2026-03-15 fix(PCB): 调优放电/预充电阻功率与母线采样布局
2026-03-15 refactor(PCB): 优化线宽
